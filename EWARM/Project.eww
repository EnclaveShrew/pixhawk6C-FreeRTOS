<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\pixhawk6-bare-fc.ewp</path>
  </project>
  <batchBuild />
</workspace>
